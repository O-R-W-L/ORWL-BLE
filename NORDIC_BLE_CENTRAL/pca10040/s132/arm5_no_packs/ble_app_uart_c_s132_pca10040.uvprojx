# Keil uVision project ble_app_uart_c_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BSP_UART_SUPPORT SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0 NRF_LOG_USES_UART=1
  c include: ..\..\..\config\ble_app_uart_c_s132_pca10040;..\..\..\config;..\..\..\..\common\components\ble\ble_db_discovery;..\..\..\..\common\components\ble\ble_services\ble_nus_c;..\..\..\..\common\components\ble\common;..\..\..\..\common\components\drivers_nrf\common;..\..\..\..\common\components\drivers_nrf\config;..\..\..\..\common\components\drivers_nrf\delay;..\..\..\..\common\components\drivers_nrf\gpiote;..\..\..\..\common\components\drivers_nrf\hal;..\..\..\..\common\components\drivers_nrf\uart;..\..\..\..\common\components\libraries\button;..\..\..\..\common\components\libraries\fifo;..\..\..\..\common\components\libraries\timer;..\..\..\..\common\components\libraries\trace;..\..\..\..\common\components\libraries\uart;..\..\..\..\common\components\libraries\util;..\..\..\..\common\components\softdevice\common\softdevice_handler;..\..\..\..\common\components\softdevice\s132\headers;..\..\..\..\common\components\softdevice\s132\headers\nrf52;..\..\..\..\common\components\toolchain;..\..\..\..\common\bsp;..\..\..\..\common\external\segger_rtt;..\..\..\..\common\components\drivers_nrf\spi_slave;..\..\..\..\common\components\drivers_nrf\twis_slave;..\..\..\..\common\components\drivers_nrf\ble_flash
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20001eb0 size 0xe150
  group Application
    ../../../: main.c eeprom_simulator.c
  group Board Support
    ../../../../common/bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../common/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../common/components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../common/components/ble/ble_services/ble_nus_c/: ble_nus_c.c
  group nRF_Drivers
    ../../../../common/components/libraries/uart/: app_uart_fifo.c
    ../../../../common/components/drivers_nrf/delay/: nrf_delay.c
    ../../../../common/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../common/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../common/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../common/components/drivers_nrf/twis_slave/: nrf_drv_twis.c
    ../../../../common/components/drivers_nrf/ble_flash/: ble_flash.c
  group nRF_Libraries
    ../../../../common/components/libraries/button/: app_button.c
    ../../../../common/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../common/components/libraries/fifo/: app_fifo.c
    ../../../../common/components/libraries/timer/: app_timer.c
    ../../../../common/components/libraries/trace/: app_trace.c
    ../../../../common/components/libraries/uart/: retarget.c
  group nRF_Segger_RTT
    ../../../../common/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../common/components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
    ../../../../common/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_uart_c_s132_pca10040;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20001eb0 size 0xe150
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
